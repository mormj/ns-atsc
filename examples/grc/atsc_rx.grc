options:
  parameters:
    generate_options: no_gui
    id: atsc_rx
    output_language: python
    run_options: run
    title: ATSC Receiver
  states: {}

blocks:
- name: atsc_sym_rate
  id: variable
  parameters:
    value: 4.5e6 / 286 * 684
  states: {}
- name: oversampled_rate
  id: variable
  parameters:
    value: atsc_sym_rate * sps
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '1.1'
  states: {}
- name: analog_agc_0
  id: analog_agc
  parameters:
    T: float
    domain: cpu
    gain: '1.0'
    rate: '1e-4'
    reference: '1.0'
  states: {}
- name: atsc_deinterleaver_0
  id: atsc_deinterleaver
  parameters:
    domain: cpu
  states: {}
- name: atsc_derandomizer_0
  id: atsc_derandomizer
  parameters:
    domain: cpu
  states: {}
- name: atsc_equalizer_0
  id: atsc_equalizer
  parameters:
    domain: cpu
  states: {}
- name: atsc_fpll_0
  id: atsc_fpll
  parameters:
    domain: cpu
    rate: oversampled_rate
  states: {}
- name: atsc_fs_checker_0
  id: atsc_fs_checker
  parameters:
    domain: cpu
  states: {}
- name: atsc_rs_decoder_0
  id: atsc_rs_decoder
  parameters:
    domain: cpu
  states: {}
- name: atsc_sync_0
  id: atsc_sync
  parameters:
    domain: cpu
    rate: oversampled_rate
  states: {}
- name: atsc_viterbi_decoder_0
  id: atsc_viterbi_decoder
  parameters:
    domain: cpu
  states: {}
- name: fileio_file_sink_0
  id: fileio_file_sink
  parameters:
    append: 'False'
    domain: cpu
    filename: /tmp/mpeg.live.ts
    itemsize: gr.sizeof_char*188
  states: {}
- name: fileio_file_source_0
  id: fileio_file_source
  parameters:
    domain: cpu
    filename: /data/data/capt_20msps_539mhz._2xsymrate.sc16
    itemsize: 2*gr.sizeof_short
    len: '0'
    offset: '0'
    repeat: 'False'
  states: {}
- name: filter_dc_blocker_0
  id: filter_dc_blocker
  parameters:
    D: '4096'
    T: float
    domain: cpu
    long_form: 'True'
  states: {}
- name: streamops_interleaved_short_to_complex_0
  id: streamops_interleaved_short_to_complex
  parameters:
    domain: cpu
    scale_factor: '32768.0'
    swap: 'False'
  states: {}

connections:
- [analog_agc_0, '0', atsc_sync_0, '0']
- [atsc_deinterleaver_0, '0', atsc_rs_decoder_0, '0']
- [atsc_deinterleaver_0, '1', atsc_rs_decoder_0, '1']
- [atsc_derandomizer_0, '0', fileio_file_sink_0, '0']
- [atsc_equalizer_0, '0', atsc_viterbi_decoder_0, '0']
- [atsc_equalizer_0, '1', atsc_viterbi_decoder_0, '1']
- [atsc_fpll_0, '0', filter_dc_blocker_0, '0']
- [atsc_fs_checker_0, '0', atsc_equalizer_0, '0']
- [atsc_fs_checker_0, '1', atsc_equalizer_0, '1']
- [atsc_rs_decoder_0, '0', atsc_derandomizer_0, '0']
- [atsc_rs_decoder_0, '1', atsc_derandomizer_0, '1']
- [atsc_sync_0, '0', atsc_fs_checker_0, '0']
- [atsc_viterbi_decoder_0, '0', atsc_deinterleaver_0, '0']
- [atsc_viterbi_decoder_0, '1', atsc_deinterleaver_0, '1']
- [fileio_file_source_0, '0', streamops_interleaved_short_to_complex_0, '0']
- [filter_dc_blocker_0, '0', analog_agc_0, '0']
- [streamops_interleaved_short_to_complex_0, '0', atsc_fpll_0, '0']

metadata:
  file_format: 1
